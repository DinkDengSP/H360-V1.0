<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ProjectCollection\Application\ProjectFiles\RailAppV2.4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ProjectCollection\BootLoader\ProjectFiles\RailBootV2.4.ewp</path>
    </project>
    <batchBuild />
</workspace>
