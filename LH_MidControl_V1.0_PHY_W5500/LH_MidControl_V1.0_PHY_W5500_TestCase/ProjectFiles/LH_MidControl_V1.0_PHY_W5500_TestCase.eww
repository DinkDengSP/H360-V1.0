<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LH_MidControl_V1.0_PHY_W5500_TestCase.ewp</path>
    </project>
    <batchBuild />
</workspace>
