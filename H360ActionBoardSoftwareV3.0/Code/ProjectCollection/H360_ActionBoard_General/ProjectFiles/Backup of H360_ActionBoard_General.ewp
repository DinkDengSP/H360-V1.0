# IAR project Backup of H360_ActionBoard_General.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\CommonFunc; ..\..\..\CommonFunc\CanProtocol; ..\..\..\CommonFunc\CanSubSystem; ..\..\..\CommonFunc\StepMotor; ..\..\..\CommonService\ServiceIpc; ..\..\..\CommonService\ServiceTask\ServiceImpl; ..\..\..\CommonService\ServiceTask; ..\..\..\CommonService; ..\..\..\Driver\DriverBoard; ..\..\..\Driver\DriverMCU; ..\..\..\Driver\DriverCore\CMSIS; ..\..\..\Driver\DriverCore\Startup; ..\..\..\Driver\DriverCore\StdLib\inc; ..\..\..\Driver\DriverCore\StdLib\src; ..\..\..\Driver\DriverCore\StdLibSupport; ..\..\..\Driver\DriverCore\UtilFunc; ..\..\..\UCOS3.07\BSP; ..\..\..\UCOS3.07\uC-CPU\Port; ..\..\..\UCOS3.07\uC-CPU\Source; ..\..\..\UCOS3.07\uC-LIB; ..\..\..\UCOS3.07\uCOS-III\Port; ..\..\..\UCOS3.07\uCOS-III\Source; ..\DriverConfig\BoardConfig; ..\DriverConfig\CoreConfig; ..\DriverConfig\StepMotorConfig; ..\DriverConfig\UCosConfig; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\AppSupport\AppIpc; ..\TaskMain\AppSupport\AppTask\AppImpl; ..\TaskMain\AppSupport\AppTask; ..\TaskMain\AppSupport\AppUtil; ..\TaskMain\ServiceSupport\ServiceIpc; ..\TaskMain\ServiceSupport\ServiceTask\ServiceImpl; ..\TaskMain\ServiceSupport\ServiceTask; ..\TaskMain\ServiceSupport\ServiceUtil
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: H360_ActionBoard_General.bin
  ILINK.IlinkOutputFile: H360_ActionBoard_General.out
  ILINK.IlinkIcfFile: ..\..\..\Driver\DriverCore\Startup\stm32f407xG_Application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CommomFunc
    ../../../CommonFunc/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h CommonFuncInc.h ErrorCode.h SystemCmd.h UserMemManager.c UserMemManager.h
  group CommomFunc/CanProtocol
    ../../../CommonFunc/CanProtocol/: CanBaseCommon.c CanBaseCommon.h CanMasterDataTypeConfig.h CanMasterMain.c CanMasterMain.h CanMasterUtil.c CanMasterUtil.h CanSlaveDataTypeConfig.h CanSlaveMain.c CanSlaveMain.h CanSlaveUtil.c CanSlaveUtil.h
  group CommomFunc/CanSubSystem
    ../../../CommonFunc/CanSubSystem/: CanSubInput.c CanSubInput.h CanSubInputIndex.h CanSubOutput.c CanSubOutput.h CanSubOutputIndex.h CanSubSerialRS1.c CanSubSerialRS1.h CanSubSerialRS2.c CanSubSerialRS2.h CanSubStepMotor.c CanSubStepMotor.h CanSubStepMotorIndex.h
  group CommomFunc/StepMotor
    ../../../CommonFunc/StepMotor/: StepMotor.c StepMotor.h StepMotorAlarm.c StepMotorAlarm.h StepMotorDACC.c StepMotorParam.c StepMotorParam.h StepMotorParamProtocol.c StepMotorReset.c StepMotorReturnZero.c StepMotorRunAlways.c StepMotorRunCoordinate.c StepMotorRunStep.c StepMotorTable.c StepMotorTable.h StepMotorType.h StepMotorUtil.c StepMotorUtil.h
  group CommonService
    ../../../CommonService/: SvnVersion.h
  group CommonService/ServiceIpc
    ../../../CommonService/ServiceIpc/: CommonServiceIpcBase.h CommonServiceIpcInc.h ServiceIpcInput.c ServiceIpcInput.h ServiceIpcOutput.c ServiceIpcOutput.h ServiceIpcStepMotor1.c ServiceIpcStepMotor1.h ServiceIpcStepMotor10.c ServiceIpcStepMotor10.h ServiceIpcStepMotor11.c ServiceIpcStepMotor11.h ServiceIpcStepMotor12.c ServiceIpcStepMotor12.h ServiceIpcStepMotor2.c ServiceIpcStepMotor2.h ServiceIpcStepMotor3.c ServiceIpcStepMotor3.h ServiceIpcStepMotor4.c ServiceIpcStepMotor4.h ServiceIpcStepMotor5.c ServiceIpcStepMotor5.h ServiceIpcStepMotor6.c ServiceIpcStepMotor6.h ServiceIpcStepMotor7.c ServiceIpcStepMotor7.h ServiceIpcStepMotor8.c ServiceIpcStepMotor8.h ServiceIpcStepMotor9.c ServiceIpcStepMotor9.h
  group CommonService/ServiceTask
    ../../../CommonService/ServiceTask/: ServiceTaskDebugIAP.c ServiceTaskInput.c ServiceTaskOutput.c ServiceTaskParam.c ServiceTaskStepMotor1.c ServiceTaskStepMotor10.c ServiceTaskStepMotor11.c ServiceTaskStepMotor12.c ServiceTaskStepMotor2.c ServiceTaskStepMotor3.c ServiceTaskStepMotor4.c ServiceTaskStepMotor5.c ServiceTaskStepMotor6.c ServiceTaskStepMotor7.c ServiceTaskStepMotor8.c ServiceTaskStepMotor9.c
  group CommonService/ServiceTask/ServiceImpl
    ../../../CommonService/ServiceTask/ServiceImpl/: CommonServiceImplBase.h CommonServiceImplInc.h ServiceImplDebugIAP.c ServiceImplDebugIAP.h ServiceImplDebugMsg.c ServiceImplInput.c ServiceImplInput.h ServiceImplOutput.c ServiceImplOutput.h ServiceImplParam.c ServiceImplParam.h ServiceImplStepMotor.c ServiceImplStepMotor.h
  group Driver/DriverBoard
    ../../../Driver/DriverBoard/: BoardCPLD.c BoardCPLD.h BoardEncoder.c BoardEncoder.h BoardExti.c BoardExti.h BoardIAP.c BoardIAP.h BoardInc.h BoardInOut.c BoardInOut.h BoardKeyID.c BoardKeyID.h BoardLed.c BoardLed.h BoardLiqudiDetect.c BoardLiquidDetect.h BoardMB85RS2MT.c BoardMB85RS2MT.h BoardPMT.c BoardPMT.h BoardRS.c BoardRS.h BoardSRAM.c BoardSRAM.h
  group Driver/DriverCore/CMSIS
    ../../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Driver/DriverCore/Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s stm32f407xG_Application.icf
  group Driver/DriverCore/StdLib/inc
    ../../../Driver/DriverCore/StdLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Driver/DriverCore/StdLib/src
    ../../../Driver/DriverCore/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver/DriverCore/StdLibSupport
    ../../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Driver/DriverCore/UtilFunc
    ../../../Driver/DriverCore/UtilFunc/: CoreDelay.c CoreDelay.h CoreInc.h CoreUtil.c CoreUtil.h
  group Driver/DriverMCU
    ../../../Driver/DriverMCU/: MCU_Can.c MCU_Can.h MCU_Flash.c MCU_Flash.h MCU_Inc.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SPI.c MCU_SPI.h MCU_Timer.c MCU_Timer.h MCU_Uart1.c MCU_Uart1.h MCU_Uart3.c MCU_Uart3.h MCU_UartCommon.h MCU_Wdg.c MCU_Wdg.h
  group ProjectFiles/DriverConfig/BoardConfig
    ../DriverConfig/BoardConfig/: BoardConfigInc.h BoardInInitPull.c BoardOutInitConfig.c
  group ProjectFiles/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_it.c system_stm32f4xx.c
  group ProjectFiles/DriverConfig/StepMotorConfig
    ../DriverConfig/StepMotorConfig/: StepMotor10DefaultSetting.c StepMotor11DefaultSetting.c StepMotor12DefaultSetting.c StepMotor1DefaultSetting.c StepMotor2DefaultSetting.c StepMotor3DefaultSetting.c StepMotor4DefaultSetting.c StepMotor5DefaultSetting.c StepMotor6DefaultSetting.c StepMotor7DefaultSetting.c StepMotor8DefaultSetting.c StepMotor9DefaultSetting.c
  group ProjectFiles/DriverConfig/UCosConfig
    ../DriverConfig/UCosConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ProjectFiles/DriverConfig/UserConfig
    ../DriverConfig/UserConfig/: SelfBoardID.h UserMemManagerConfig.h
  group ProjectFiles/TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h SystemTaskStart.c
  group ProjectFiles/TaskMain/AppSupport/AppIpc
    ../TaskMain/AppSupport/AppIpc/: AppIpcBase.h AppIpcInc.h AppIpcOther.c AppIpcOther.h
  group ProjectFiles/TaskMain/AppSupport/AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskConfig.h AppTaskOther.c
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl
    ../TaskMain/AppSupport/AppTask/AppImpl/: AppImplBase.h AppImplDebugMsg.c AppImplInc.h AppImplOther.c AppImplOther.h
  group ProjectFiles/TaskMain/AppSupport/AppUtil
    ../TaskMain/AppSupport/AppUtil/: AppUtilMsg.c AppUtilMsg.h AppUtilParam.c AppUtilParam.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceIpc
    ../TaskMain/ServiceSupport/ServiceIpc/: ServiceIpcBase.h ServiceIpcInc.h ServiceIpcSerialDebugRS2.c ServiceIpcSerialDebugRS2.h ServiceIpcSerialUserRS1.c ServiceIpcSerialUserRS1.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskCan1Recv.c ServiceTaskConfig.h ServiceTaskHeart.c ServiceTaskSerialDebugRS2.c ServiceTaskSerialUserRS1.c
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask/ServiceImpl
    ../TaskMain/ServiceSupport/ServiceTask/ServiceImpl/: ServiceImplBase.h ServiceImplInc.h ServiceImplSerialDebugRS2.c ServiceImplSerialDebugRS2.h ServiceImplSerialUserRS1.c ServiceImplSerialUserRS1.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceUtil
    ../TaskMain/ServiceSupport/ServiceUtil/: ServiceUtilMsg.c ServiceUtilMsg.h ServiceUtilParam.c ServiceUtilParam.h
  group UCOS3.07/BSP
    ../../../UCOS3.07/BSP/: bsp_user.c bsp_user.h
  group UCOS3.07/uC-CPU/Port
    ../../../UCOS3.07/uC-CPU/Port/: cpu.h cpu_a.asm cpu_c.c
  group UCOS3.07/uC-CPU/Source
    ../../../UCOS3.07/uC-CPU/Source/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOS3.07/uC-LIB
    ../../../UCOS3.07/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS3.07/uCOS-III/Port
    ../../../UCOS3.07/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS3.07/uCOS-III/Source
    ../../../UCOS3.07/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
