# IAR project H360_ActionBoard_ID_1.ewp, settings and files
configuration H360_Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; BOARD_TYPE_H360
  ICCARM.CCIncludePath2: ..\..\..\CommonFunc\SystemUtil; ..\..\..\CommonFunc\RTT; ..\..\..\CommonFunc\CanProtocol; ..\..\..\CommonFunc\CanSubSystem; ..\..\..\CommonFunc\CanSubBoard1; ..\..\..\CommonFunc\CanSubBoard2; ..\..\..\CommonFunc\CanSubBoard3; ..\..\..\CommonFunc\CanSubBoard4; ..\..\..\CommonFunc\CanSubBoard5; ..\..\..\CommonFunc\StepMotor; ..\..\..\CommonService\ServiceIpc; ..\..\..\CommonService\ServiceTask\ServiceImpl; ..\..\..\CommonService\ServiceTask; ..\..\..\CommonService; ..\..\..\Driver\DriverBoard; ..\..\..\Driver\DriverMCU; ..\..\..\Driver\DriverCore\CMSIS; ..\..\..\Driver\DriverCore\Startup; ..\..\..\Driver\DriverCore\StdLib\inc; ..\..\..\Driver\DriverCore\StdLib\src; ..\..\..\Driver\DriverCore\StdLibSupport; ..\..\..\Driver\DriverCore\UtilFunc; ..\..\..\UCOS3.07\BSP; ..\..\..\UCOS3.07\uC-CPU\Port; ..\..\..\UCOS3.07\uC-CPU\Source; ..\..\..\UCOS3.07\uC-LIB; ..\..\..\UCOS3.07\uCOS-III\Port; ..\..\..\UCOS3.07\uCOS-III\Source; ..\DriverConfig\BoardConfig; ..\DriverConfig\CoreConfig; ..\DriverConfig\StepMotorConfig; ..\DriverConfig\UCosConfig; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\AppSupport\AppIpc; ..\TaskMain\AppSupport\AppTask\AppImpl; ..\TaskMain\AppSupport\AppTask\AppImpl\AppImplVersion0; ..\TaskMain\AppSupport\AppTask\AppImpl\AppImplVersion1; ..\TaskMain\AppSupport\AppTask; ..\TaskMain\AppSupport\AppUtil; ..\TaskMain\ServiceSupport\ServiceIpc; ..\TaskMain\ServiceSupport\ServiceTask\ServiceImpl; ..\TaskMain\ServiceSupport\ServiceTask; ..\TaskMain\ServiceSupport\ServiceUtil; ..\TaskMain\AppSupport\AppTask\AppImpl\AppImplVersion2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Imm_H360_Act1_V1.0.bin
  ILINK.IlinkOutputFile: H360_ActionBoard_ID_1.out
  ILINK.IlinkIcfFile: ..\..\..\Driver\DriverCore\Startup\stm32f407xG_Application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration H360S_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; BOARD_TYPE_H360S
  OBJCOPY.OOCOutputFile: Imm_H360S_Act1_V01.00.00.bin
  ILINK.IlinkOutputFile: H360S_ActionBoard_ID_1.out
  group CommomFunc/CanProtocol
    ../../../CommonFunc/CanProtocol/: CanBaseCommon.c CanBaseCommon.h CanMasterDataTypeConfig.h CanMasterMain.c CanMasterMain.h CanMasterUtil.c CanMasterUtil.h CanSlaveDataTypeConfig.h CanSlaveMain.c CanSlaveMain.h CanSlaveUtil.c CanSlaveUtil.h
  group CommomFunc/CanSubBoard1
    ../../../CommonFunc/CanSubBoard1/: CanSubBoard1BufferSolutionInject.c CanSubBoard1BufferSolutionInject.h CanSubBoard1Inc.h CanSubBoard1LiquidAuto.c CanSubBoard1LiquidAuto.h CanSubBoard1LiquidExcite.c CanSubBoard1LiquidExcite.h CanSubBoard1LiquidNeedleBead.c CanSubBoard1LiquidNeedleBead.h CanSubBoard1LiquidNeedleReagent.c CanSubBoard1LiquidNeedleReagent.h CanSubBoard1LiquidNeedleSample.c CanSubBoard1LiquidNeedleSample.h CanSubBoard1MixWash.c CanSubBoard1MixWash.h CanSubBoard1NeedleWash.c CanSubBoard1NeedleWash.h CanSubBoard1Param.c CanSubBoard1Param.h CanSubBoard1PlateWash.c CanSubBoard1PlateWash.h
  group CommomFunc/CanSubBoard2
    ../../../CommonFunc/CanSubBoard2/: CanSubBoard2CupTrayStackManage.c CanSubBoard2CupTrayStackManage.h CanSubBoard2Inc.h CanSubBoard2NeedleBead.c CanSubBoard2NeedleBead.h CanSubBoard2Param.c CanSubBoard2Param.h CanSubBoard2PlateReagent.c CanSubBoard2PlateReagent.h
  group CommomFunc/CanSubBoard3
    ../../../CommonFunc/CanSubBoard3/: CanSubBoard3HandWash.c CanSubBoard3HandWash.h CanSubBoard3Inc.h CanSubBoard3MeasureModule.c CanSubBoard3MeasureModule.h CanSubBoard3Param.c CanSubBoard3Param.h
  group CommomFunc/CanSubBoard4
    ../../../CommonFunc/CanSubBoard4/: CanSubBoard4Inc.h CanSubBoard4MixBead.c CanSubBoard4MixBead.h CanSubBoard4MixReagent.c CanSubBoard4MixReagent.h CanSubBoard4NeedleReagent.c CanSubBoard4NeedleReagent.h CanSubBoard4Param.c CanSubBoard4Param.h CanSubBoard4PlateReaction.c CanSubBoard4PlateReaction.h
  group CommomFunc/CanSubBoard5
    ../../../CommonFunc/CanSubBoard5/: CanSubBoard5HandNewCup.c CanSubBoard5HandNewCup.h CanSubBoard5Inc.h CanSubBoard5NeedleSample.c CanSubBoard5NeedleSample.h CanSubBoard5Param.c CanSubBoard5Param.h CanSubBoard5SampleRackTrack.c CanSubBoard5SampleRackTrack.h
  group CommomFunc/CanSubSystem
    ../../../CommonFunc/CanSubSystem/: CanSubBase.c CanSubBase.h CanSubInput.c CanSubInput.h CanSubInputIndex.h CanSubOutput.c CanSubOutput.h CanSubOutputIndex.h CanSubSerialRS1.c CanSubSerialRS1.h CanSubSerialRS2.c CanSubSerialRS2.h CanSubStepMotor.c CanSubStepMotor.h CanSubStepMotorIndex.h
  group CommomFunc/RTT
    ../../../CommonFunc/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group CommomFunc/StepMotor
    ../../../CommonFunc/StepMotor/: StepMotor.c StepMotor.h StepMotorAlarm.c StepMotorAlarm.h StepMotorDACC.c StepMotorParam.c StepMotorParam.h StepMotorParamProtocol.c StepMotorReset.c StepMotorReturnZero.c StepMotorRunAlways.c StepMotorRunCoordinate.c StepMotorRunStep.c StepMotorTable.c StepMotorTable.h StepMotorType.h StepMotorUtil.c StepMotorUtil.h
  group CommomFunc/SystemUtil
    ../../../CommonFunc/SystemUtil/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ADT_CirclePtrQueue.c ADT_CirclePtrQueue.h CommonFuncInc.h ErrorCode.h SystemCmd.h SystemMode.c SystemMode.h SystemVersion.h UserMemManager.c UserMemManager.h
  group CommonService/ServiceIpc
    ../../../CommonService/ServiceIpc/: CommonServiceIpcBase.h CommonServiceIpcInc.h ServiceIpcInput.c ServiceIpcInput.h ServiceIpcOutput.c ServiceIpcOutput.h ServiceIpcStepMotor.c ServiceIpcStepMotor.h ServiceIpcStepMotor1.c ServiceIpcStepMotor1.h ServiceIpcStepMotor10.c ServiceIpcStepMotor10.h ServiceIpcStepMotor11.c ServiceIpcStepMotor11.h ServiceIpcStepMotor12.c ServiceIpcStepMotor12.h ServiceIpcStepMotor2.c ServiceIpcStepMotor2.h ServiceIpcStepMotor3.c ServiceIpcStepMotor3.h ServiceIpcStepMotor4.c ServiceIpcStepMotor4.h ServiceIpcStepMotor5.c ServiceIpcStepMotor5.h ServiceIpcStepMotor6.c ServiceIpcStepMotor6.h ServiceIpcStepMotor7.c ServiceIpcStepMotor7.h ServiceIpcStepMotor8.c ServiceIpcStepMotor8.h ServiceIpcStepMotor9.c ServiceIpcStepMotor9.h
  group CommonService/ServiceTask
    ../../../CommonService/ServiceTask/: ServiceTaskDebugIAP.c ServiceTaskInput.c ServiceTaskOutput.c ServiceTaskParam.c ServiceTaskStepMotor1.c ServiceTaskStepMotor10.c ServiceTaskStepMotor11.c ServiceTaskStepMotor12.c ServiceTaskStepMotor2.c ServiceTaskStepMotor3.c ServiceTaskStepMotor4.c ServiceTaskStepMotor5.c ServiceTaskStepMotor6.c ServiceTaskStepMotor7.c ServiceTaskStepMotor8.c ServiceTaskStepMotor9.c
  group CommonService/ServiceTask/ServiceImpl
    ../../../CommonService/ServiceTask/ServiceImpl/: CommonServiceImplBase.c CommonServiceImplBase.h CommonServiceImplInc.h ServiceImplDebugIAP.c ServiceImplDebugIAP.h ServiceImplInput.c ServiceImplInput.h ServiceImplOutput.c ServiceImplOutput.h ServiceImplParam.c ServiceImplParam.h ServiceImplStepMotor1.c ServiceImplStepMotor1.h ServiceImplStepMotor10.c ServiceImplStepMotor10.h ServiceImplStepMotor11.c ServiceImplStepMotor11.h ServiceImplStepMotor12.c ServiceImplStepMotor12.h ServiceImplStepMotor2.c ServiceImplStepMotor2.h ServiceImplStepMotor3.c ServiceImplStepMotor3.h ServiceImplStepMotor4.c ServiceImplStepMotor4.h ServiceImplStepMotor5.c ServiceImplStepMotor5.h ServiceImplStepMotor6.c ServiceImplStepMotor6.h ServiceImplStepMotor7.c ServiceImplStepMotor7.h ServiceImplStepMotor8.c ServiceImplStepMotor8.h ServiceImplStepMotor9.c ServiceImplStepMotor9.h
  group Driver/DriverBoard
    ../../../Driver/DriverBoard/: BoardBarScanCM300I.c BoardBarScanCM300I.h BoardBarscanCR100M.c BoardBarScanCR100M.h BoardCPLD.c BoardCPLD.h BoardEncoder.c BoardEncoder.h BoardExti.c BoardExti.h BoardIAP.c BoardIAP.h BoardInc.h BoardInOut.c BoardInOut.h BoardKeyID.c BoardKeyID.h BoardLed.c BoardLed.h BoardLiqudiDetect.c BoardLiquidDetect.h BoardMB85RS2MT.c BoardMB85RS2MT.h BoardPMT.c BoardPMT.h BoardRS.c BoardRS.h BoardSRAM.c BoardSRAM.h BoardVersion.c BoardVersion.h
  group Driver/DriverCore/CMSIS
    ../../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Driver/DriverCore/Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s stm32f407xG_Application.icf
  group Driver/DriverCore/StdLib/inc
    ../../../Driver/DriverCore/StdLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Driver/DriverCore/StdLib/src
    ../../../Driver/DriverCore/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver/DriverCore/StdLibSupport
    ../../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Driver/DriverCore/UtilFunc
    ../../../Driver/DriverCore/UtilFunc/: CoreDelay.c CoreDelay.h CoreInc.h CoreUtil.c CoreUtil.h
  group Driver/DriverMCU
    ../../../Driver/DriverMCU/: MCU_Can.c MCU_Can.h MCU_Flash.c MCU_Flash.h MCU_Inc.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SPI.c MCU_SPI.h MCU_Timer.c MCU_Timer.h MCU_Uart1.c MCU_Uart1.h MCU_Uart3.c MCU_Uart3.h MCU_UartCommon.h MCU_Wdg.c MCU_Wdg.h
  group ProjectFiles/DriverConfig/BoardConfig
    ../DriverConfig/BoardConfig/: BoardConfigInc.h BoardInInitPull.c BoardOutInitConfig.c
  group ProjectFiles/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_it.c system_stm32f4xx.c
  group ProjectFiles/DriverConfig/StepMotorConfig
    ../DriverConfig/StepMotorConfig/: StepMotor10DefaultSetting.c StepMotor11DefaultSetting.c StepMotor12DefaultSetting.c StepMotor1DefaultSetting.c StepMotor2DefaultSetting.c StepMotor3DefaultSetting.c StepMotor4DefaultSetting.c StepMotor5DefaultSetting.c StepMotor6DefaultSetting.c StepMotor7DefaultSetting.c StepMotor8DefaultSetting.c StepMotor9DefaultSetting.c
  group ProjectFiles/DriverConfig/UCosConfig
    ../DriverConfig/UCosConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ProjectFiles/DriverConfig/UserConfig
    ../DriverConfig/UserConfig/: SelfBoardID.h UserMemManagerConfig.h
  group ProjectFiles/TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h SystemTaskStart.c
  group ProjectFiles/TaskMain/AppSupport/AppIpc
    ../TaskMain/AppSupport/AppIpc/: AppIpcBase.c AppIpcBase.h AppIpcBufferInject.c AppIpcBufferInject.h AppIpcInc.h AppIpcLiquidAuto.c AppIpcLiquidAuto.h AppIpcLiquidExcite.c AppIpcLiquidExcite.h AppIpcLiquidNeedleBead.c AppIpcLiquidNeedleBead.h AppIpcLiquidNeedleReagent.c AppIpcLiquidNeedleReagent.h AppIpcLiquidNeedleSample.c AppIpcLiquidNeedleSample.h AppIpcMixWash.c AppIpcMixWash.h AppIpcNeedleWash.c AppIpcNeedleWash.h AppIpcParam.c AppIpcParam.h AppIpcPlateWash.c AppIpcPlateWash.h AppIpcSync.c AppIpcSync.h
  group ProjectFiles/TaskMain/AppSupport/AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskBufferInject.c AppTaskConfig.h AppTaskLiquidAuto.c AppTaskLiquidExcite.c AppTaskLiquidNeedleBead.c AppTaskLiquidNeedleReagent.c AppTaskLiquidNeedleSample.c AppTaskMixWash.c AppTaskNeedleWash.c AppTaskParam.c AppTaskPlateWash.c AppTaskSync.c
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl
    ../TaskMain/AppSupport/AppTask/AppImpl/: AppImplBase.c AppImplBase.h AppImplBufferInject.c AppImplBufferInject.h AppImplInc.h AppImplLiquidAuto.c AppImplLiquidAuto.h AppImplLiquidExcite.c AppImplLiquidExcite.h AppImplLiquidNeedleBead.c AppImplLiquidNeedleBead.h AppImplLiquidNeedleReagent.c AppImplLiquidNeedleReagent.h AppImplLiquidNeedleSample.c AppImplLiquidNeedleSample.h AppImplMixWash.c AppImplMixWash.h AppImplNeedleWash.c AppImplNeedleWash.h AppImplParam.c AppImplParam.h AppImplPlateWash.c AppImplPlateWash.h AppImplSync.c AppImplSync.h
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion0
    ../TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion0/: AppImplBufferInjectConfigVersion0.h AppImplBufferInjectVersion0.c AppImplBufferInjectVersion0.h AppImplLiquidAutoConfigVersion0.h AppImplLiquidAutoVersion0.c AppImplLiquidAutoVersion0.h AppImplLiquidExciteVersion0.c AppImplLiquidExciteVersion0.h AppImplLiquidNeedleBeadVersion0.c AppImplLiquidNeedleBeadVersion0.h AppImplLiquidNeedleReagentVersion0.c AppImplLiquidNeedleReagentVersion0.h AppImplLiquidNeedleSampleVersion0.c AppImplLiquidNeedleSampleVersion0.h AppImplMixWashConfigVersion0.h AppImplMixWashVersion0.c AppImplMixWashVersion0.h AppImplNeedleWashConfigVersion0.h AppImplNeedleWashVersion0.c AppImplNeedleWashVersion0.h AppImplPlateWashConfigVersion0.h AppImplPlateWashVersion0.c AppImplPlateWashVersion0.h AppLiquidUtilConfigVersion0.h AppLiquidUtilVersion0.c AppLiquidUtilVersion0.h
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion1
    ../TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion1/: AppImplBufferInjectConfigVersion1.h AppImplBufferInjectVersion1.c AppImplBufferInjectVersion1.h AppImplLiquidAutoConfigVersion1.h AppImplLiquidAutoVersion1.c AppImplLiquidAutoVersion1.h AppImplLiquidExciteVersion1.c AppImplLiquidExciteVersion1.h AppImplLiquidNeedleBeadVersion1.c AppImplLiquidNeedleBeadVersion1.h AppImplLiquidNeedleReagentVersion1.c AppImplLiquidNeedleReagentVersion1.h AppImplLiquidNeedleSampleVersion1.c AppImplLiquidNeedleSampleVersion1.h AppImplMixWashConfigVersion1.h AppImplMixWashVersion1.c AppImplMixWashVersion1.h AppImplNeedleWashConfigVersion1.h AppImplNeedleWashVersion1.c AppImplNeedleWashVersion1.h AppImplPlateWashConfigVersion1.h AppImplPlateWashVersion1.c AppImplPlateWashVersion1.h AppLiquidUtilConfigVersion1.h AppLiquidUtilVersion1.c AppLiquidUtilVersion1.h
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion2
    ../TaskMain/AppSupport/AppTask/AppImpl/AppImplVersion2/: AppImplBufferInjectConfigVersion2.h AppImplBufferInjectVersion2.c AppImplBufferInjectVersion2.h AppImplLiquidExciteVersion2.c AppImplLiquidExciteVersion2.h
  group ProjectFiles/TaskMain/AppSupport/AppUtil
    ../TaskMain/AppSupport/AppUtil/: AppParam.c AppParam.h AppParamDefault.c AppParamDefault.h AppParamIndex.h AppParamType.h AppState.c AppState.h AppStateDefault.c AppStateDefault.h AppStateType.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceIpc
    ../TaskMain/ServiceSupport/ServiceIpc/: ServiceIpcBase.h ServiceIpcInc.h ServiceIpcSerialUserRS1.c ServiceIpcSerialUserRS1.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskCan1Recv.c ServiceTaskConfig.h ServiceTaskHeart.c ServiceTaskSerialDebugRS2.c ServiceTaskSerialUserRS1.c
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask/ServiceImpl
    ../TaskMain/ServiceSupport/ServiceTask/ServiceImpl/: ServiceImplBase.h ServiceImplInc.h ServiceImplSerialUserRS1.c ServiceImplSerialUserRS1.h
  group UCOS3.07/BSP
    ../../../UCOS3.07/BSP/: bsp_user.c bsp_user.h
  group UCOS3.07/uC-CPU/Port
    ../../../UCOS3.07/uC-CPU/Port/: cpu.h cpu_a.asm cpu_c.c
  group UCOS3.07/uC-CPU/Source
    ../../../UCOS3.07/uC-CPU/Source/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOS3.07/uC-LIB
    ../../../UCOS3.07/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS3.07/uCOS-III/Port
    ../../../UCOS3.07/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS3.07/uCOS-III/Source
    ../../../UCOS3.07/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
