#ifndef __CAN_SUB_OUTPUT_INDEX_H_
#define __CAN_SUB_OUTPUT_INDEX_H_
#include "stm32f4xx.h"

//系统内部输出端口定义
typedef enum CAN_SUB_IO_OUTPUT
{
    //下位机板1
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD1_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD1_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD1_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD1_MCU_YM_ARM4_PG15,
    //下位机板2
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD2_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD2_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD2_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD2_MCU_YM_ARM4_PG15,
    //下位机板3
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD3_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD3_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD3_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD3_MCU_YM_ARM4_PG15,
    //下位机板4
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD4_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD4_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD4_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD4_MCU_YM_ARM4_PG15,
    //下位机板5
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD5_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD5_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD5_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD5_MCU_YM_ARM4_PG15,
    //下位机板6
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD6_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD6_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD6_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD6_MCU_YM_ARM4_PG15,
    //下位机板7
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD7_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD7_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD7_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD7_MCU_YM_ARM4_PG15,
    //下位机板8
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD8_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD8_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD8_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD8_MCU_YM_ARM4_PG15,
    //下位机板9
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD9_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD9_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD9_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD9_MCU_YM_ARM4_PG15,
    //下位机板10
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC1,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC2,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC3,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC4,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC5,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC6,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC7,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC8,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC9,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC10,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC11,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC12,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC13,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC14,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC15,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC16,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC17,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC18,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC19,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC20,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC21,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC22,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC23,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC24,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC25,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC26,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC27,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC28,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC29,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC30,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC31,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC32,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC33,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC34,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC35,
    CAN_SUB_OUT_PIN_BOARD10_CPLD_CDC36,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN17_PC4,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN18_PA7,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN19_PA6,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN20_PA5,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN21_PA4,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN22_PA3,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN23_PF8,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN24_PF9,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN25_PF10,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN26_PH3,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN27_PH2,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_SEN28_PA2,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_DC1_PC8,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_DC2_PG9,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_DC3_PD6,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_DC4_PI3,
    CAN_SUB_OUT_PIN_BOARD10_MCU_SLAVE_DC5_PI2,
    CAN_SUB_OUT_PIN_BOARD10_MCU_YM_ARM3_PB4,
    CAN_SUB_OUT_PIN_BOARD10_MCU_YM_ARM4_PG15,
}CAN_SUB_IO_OUTPUT;



#endif





