#ifndef __CAN_SUB_STEP_MOTOR_INDEX_H_
#define __CAN_SUB_STEP_MOTOR_INDEX_H_
#include "ErrorCode.h"

//系统下位机步进电机序号
typedef enum CAN_SUB_SM_INDEX
{
    //Board1
    CAN_SUB_BOARD1_SM1,CAN_SUB_BOARD1_SM2,CAN_SUB_BOARD1_SM3,CAN_SUB_BOARD1_SM4,
    CAN_SUB_BOARD1_SM5,CAN_SUB_BOARD1_SM6,CAN_SUB_BOARD1_SM7,CAN_SUB_BOARD1_SM8,
    CAN_SUB_BOARD1_SM9,CAN_SUB_BOARD1_SM10,CAN_SUB_BOARD1_SM11,CAN_SUB_BOARD1_SM12,
    //Board2
    CAN_SUB_BOARD2_SM1,CAN_SUB_BOARD2_SM2,CAN_SUB_BOARD2_SM3,CAN_SUB_BOARD2_SM4,
    CAN_SUB_BOARD2_SM5,CAN_SUB_BOARD2_SM6,CAN_SUB_BOARD2_SM7,CAN_SUB_BOARD2_SM8,
    CAN_SUB_BOARD2_SM9,CAN_SUB_BOARD2_SM10,CAN_SUB_BOARD2_SM11,CAN_SUB_BOARD2_SM12,
    //Board3
    CAN_SUB_BOARD3_SM1,CAN_SUB_BOARD3_SM2,CAN_SUB_BOARD3_SM3,CAN_SUB_BOARD3_SM4,
    CAN_SUB_BOARD3_SM5,CAN_SUB_BOARD3_SM6,CAN_SUB_BOARD3_SM7,CAN_SUB_BOARD3_SM8,
    CAN_SUB_BOARD3_SM9,CAN_SUB_BOARD3_SM10,CAN_SUB_BOARD3_SM11,CAN_SUB_BOARD3_SM12,
    //Board4
    CAN_SUB_BOARD4_SM1,CAN_SUB_BOARD4_SM2,CAN_SUB_BOARD4_SM3,CAN_SUB_BOARD4_SM4,
    CAN_SUB_BOARD4_SM5,CAN_SUB_BOARD4_SM6,CAN_SUB_BOARD4_SM7,CAN_SUB_BOARD4_SM8,
    CAN_SUB_BOARD4_SM9,CAN_SUB_BOARD4_SM10,CAN_SUB_BOARD4_SM11,CAN_SUB_BOARD4_SM12,
    //Board5
    CAN_SUB_BOARD5_SM1,CAN_SUB_BOARD5_SM2,CAN_SUB_BOARD5_SM3,CAN_SUB_BOARD5_SM4,
    CAN_SUB_BOARD5_SM5,CAN_SUB_BOARD5_SM6,CAN_SUB_BOARD5_SM7,CAN_SUB_BOARD5_SM8,
    CAN_SUB_BOARD5_SM9,CAN_SUB_BOARD5_SM10,CAN_SUB_BOARD5_SM11,CAN_SUB_BOARD5_SM12,
    //Board6
    CAN_SUB_BOARD6_SM1,CAN_SUB_BOARD6_SM2,CAN_SUB_BOARD6_SM3,CAN_SUB_BOARD6_SM4,
    CAN_SUB_BOARD6_SM5,CAN_SUB_BOARD6_SM6,CAN_SUB_BOARD6_SM7,CAN_SUB_BOARD6_SM8,
    CAN_SUB_BOARD6_SM9,CAN_SUB_BOARD6_SM10,CAN_SUB_BOARD6_SM11,CAN_SUB_BOARD6_SM12,
    //Board7
    CAN_SUB_BOARD7_SM1,CAN_SUB_BOARD7_SM2,CAN_SUB_BOARD7_SM3,CAN_SUB_BOARD7_SM4,
    CAN_SUB_BOARD7_SM5,CAN_SUB_BOARD7_SM6,CAN_SUB_BOARD7_SM7,CAN_SUB_BOARD7_SM8,
    CAN_SUB_BOARD7_SM9,CAN_SUB_BOARD7_SM10,CAN_SUB_BOARD7_SM11,CAN_SUB_BOARD7_SM12,
    //Board8
    CAN_SUB_BOARD8_SM1,CAN_SUB_BOARD8_SM2,CAN_SUB_BOARD8_SM3,CAN_SUB_BOARD8_SM4,
    CAN_SUB_BOARD8_SM5,CAN_SUB_BOARD8_SM6,CAN_SUB_BOARD8_SM7,CAN_SUB_BOARD8_SM8,
    CAN_SUB_BOARD8_SM9,CAN_SUB_BOARD8_SM10,CAN_SUB_BOARD8_SM11,CAN_SUB_BOARD8_SM12,
    //Board9
    CAN_SUB_BOARD9_SM1,CAN_SUB_BOARD9_SM2,CAN_SUB_BOARD9_SM3,CAN_SUB_BOARD9_SM4,
    CAN_SUB_BOARD9_SM5,CAN_SUB_BOARD9_SM6,CAN_SUB_BOARD9_SM7,CAN_SUB_BOARD9_SM8,
    CAN_SUB_BOARD9_SM9,CAN_SUB_BOARD9_SM10,CAN_SUB_BOARD9_SM11,CAN_SUB_BOARD9_SM12,
    //Board10
    CAN_SUB_BOARD10_SM1,CAN_SUB_BOARD10_SM2,CAN_SUB_BOARD10_SM3,CAN_SUB_BOARD10_SM4,
    CAN_SUB_BOARD10_SM5,CAN_SUB_BOARD10_SM6,CAN_SUB_BOARD10_SM7,CAN_SUB_BOARD10_SM8,
    CAN_SUB_BOARD10_SM9,CAN_SUB_BOARD10_SM10,CAN_SUB_BOARD10_SM11,CAN_SUB_BOARD10_SM12,
}CAN_SUB_SM_INDEX;


#endif





