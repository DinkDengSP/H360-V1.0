# IAR project Backup of LH_TC_APP.ewp, settings and files
configuration H360_Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; BOARD_TYPE_H360
  ICCARM.CCIncludePath2: ..\..\..\CommonFunc\CanProtocol; ..\..\..\CommonFunc\CommonUtil; ..\..\..\CommonFunc; ..\..\..\UCOS3.07; ..\..\..\UCOS3.07\BSP; ..\..\..\UCOS3.07\uC-CPU\Port; ..\..\..\UCOS3.07\uC-CPU\Source; ..\..\..\UCOS3.07\uC-LIB; ..\..\..\UCOS3.07\uCOS-III\Port; ..\..\..\UCOS3.07\uCOS-III\Source; ..\..\..\Driver\DriverBoard; ..\..\..\Driver\DriverMCU; ..\..\..\Driver\DriverCore\CMSIS; ..\..\..\Driver\DriverCore\Startup; ..\..\..\Driver\DriverCore\StdLibSupport; ..\..\..\Driver\DriverCore\UtilFunc; ..\..\..\Driver\DriverCore\StdLib\inc; ..\..\..\Driver\DriverCore\StdLib\src; ..\DriverConfig\CoreConfig; ..\DriverConfig\UCosConfig; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\ServiceSupport\ServiceIpc; ..\TaskMain\ServiceSupport\ServiceTask; ..\TaskMain\ServiceSupport\ServiceUtil; ..\TaskMain\ServiceSupport\ServiceTask\ServiceImpl; ..\TaskMain\AppSupport\AppIpc; ..\TaskMain\AppSupport\AppTask; ..\TaskMain\AppSupport\AppUtil; ..\TaskMain\AppSupport\AppTask\AppImpl; ..\TaskMain\ServiceSupport\ServiceTask\ServiceImpl\ServiceImplVersion0; ..\TaskMain\ServiceSupport\ServiceTask\ServiceImpl\ServiceImplVersion1; ..\..\..\CommonFunc\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Imm_H360_TC_V0.1.bin
  ILINK.IlinkOutputFile: LH_H360_TC_APP_V2.3.out
  ILINK.IlinkIcfFile: ..\..\..\Driver\DriverCore\Startup\stm32f407xG_Application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration H360S_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; BOARD_TYPE_H360S
  OBJCOPY.OOCOutputFile: Imm_H360S_TC_V01.00.00.bin
  ILINK.IlinkOutputFile: LH_H360S_TC_APP_V2.3.out
configuration H80Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; BOARD_TYPE_H80
  OBJCOPY.OOCOutputFile: Imm_H80_TC_V0.1.bin
  ILINK.IlinkOutputFile: LH_H80_TC_APP_V2.3.out
  group CommonFunc
    ../../../CommonFunc/: CommonFuncInc.h ErrorCode.h
  group CommonFunc/CanProtocol
    ../../../CommonFunc/CanProtocol/: CanBaseCommon.c CanBaseCommon.h CanSlaveDataTypeConfig.h CanSlaveMain.c CanSlaveMain.h CanSlaveUtil.c CanSlaveUtil.h
  group CommonFunc/CommonUtil
    ../../../CommonFunc/CommonUtil/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ADT_CirclePtrQueue.c ADT_CirclePtrQueue.h CRC8Cal.c CRC8Cal.h SvnVersion.h SystemCmd.h SystemMode.c SystemMode.h SystemVersion.h UserMemManager.c UserMemManager.h
  group CommonFunc/RTT
    ../../../CommonFunc/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Driver/DriverBoard
    ../../../Driver/DriverBoard/: BoardBeep.c BoardBeep.h BoardCommBase.h BoardDS18B20.c BoardDS18B20.h BoardElectricCurrentDetect.c BoardElectricCurrentDetect.h BoardFan.c BoardFan.h BoardIAP.c BoardIAP.h BoardInc.h BoardInOut.c BoardInOut.h BoardKeyID.c BoardKeyID.h BoardMax31856.c BoardMax31856.h BoardMB85RS2MT.c BoardMB85RS2MT.h BoardPlateReactionDevice.c BoardPlateReactionDevice.h BoardPlateReagentCooler.c BoardPlateReagentCooler.h BoardPlateReagentDevice.c BoardPlateReagentDevice.h BoardPlateWashDevice.c BoardPlateWashDevice.h BoardRS.c BoardRS.h BoardSystemLed.c BoardSystemLed.h BoardThermocoupleLed.c BoardThermocoupleLed.h BoardVersion.c BoardVersion.h
  group Driver/DriverCore/CMSIS
    ../../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Driver/DriverCore/Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s stm32f407xG_Application.icf
  group Driver/DriverCore/StdLib/inc
    ../../../Driver/DriverCore/StdLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Driver/DriverCore/StdLib/src
    ../../../Driver/DriverCore/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver/DriverCore/StdLibSupport
    ../../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Driver/DriverCore/UtilFunc
    ../../../Driver/DriverCore/UtilFunc/: CoreDelay.c CoreDelay.h CoreInc.h CoreUtil.c CoreUtil.h
  group Driver/DriverMCU
    ../../../Driver/DriverMCU/: MCU_ADC.c MCU_ADC.h MCU_Can.c MCU_Can.h MCU_Flash.c MCU_Flash.h MCU_Inc.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SPI.c MCU_SPI.h MCU_Uart1.c MCU_Uart1.h MCU_Uart2.c MCU_Uart2.h MCU_UartCommon.h MCU_Wdg.c MCU_Wdg.h
  group ProjectFiles/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_it.c system_stm32f4xx.c
  group ProjectFiles/DriverConfig/UCosConfig
    ../DriverConfig/UCosConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ProjectFiles/DriverConfig/UserConfig
    ../DriverConfig/UserConfig/: SelfBoardID.h SystemFuncConfig.h UserMemManagerConfig.h
  group ProjectFiles/TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h SystemTaskStart.c
  group ProjectFiles/TaskMain/AppSupport/AppIpc
    ../TaskMain/AppSupport/AppIpc/: AppIpcBase.c AppIpcBase.h AppIpcInc.h AppIpcSystemMsg.c AppIpcSystemMsg.h
  group ProjectFiles/TaskMain/AppSupport/AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskConfig.h AppTaskSystemMsg.c
  group ProjectFiles/TaskMain/AppSupport/AppTask/AppImpl
    ../TaskMain/AppSupport/AppTask/AppImpl/: AppImplBase.c AppImplBase.h AppImplInc.h AppImplSystemMsg.c AppImplSystemMsg.h
  group ProjectFiles/TaskMain/AppSupport/AppUtil
    ../TaskMain/AppSupport/AppUtil/: AppUtilMsg.c AppUtilMsg.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceIpc
    ../TaskMain/ServiceSupport/ServiceIpc/: ServiceIpcBase.c ServiceIpcBase.h ServiceIpcEnvir.c ServiceIpcEnvir.h ServiceIpcInc.h ServiceIpcPlateReaction.c ServiceIpcPlateReaction.h ServiceIpcPlateReagent.c ServiceIpcPlateReagent.h ServiceIpcPlateWash.c ServiceIpcPlateWash.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskCanRecv.c ServiceTaskConfig.h ServiceTaskDebugIAP.c ServiceTaskEnvir.c ServiceTaskHeart.c ServiceTaskParam.c ServiceTaskPlateReaction.c ServiceTaskPlateReagent.c ServiceTaskPlateWash.c ServiceTaskSensor.c
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask/ServiceImpl
    ../TaskMain/ServiceSupport/ServiceTask/ServiceImpl/: ServiceImplBase.c ServiceImplBase.h ServiceImplDebugIAP.c ServiceImplDebugIAP.h ServiceImplEnvir.c ServiceImplEnvir.h ServiceImplHeart.c ServiceImplHeart.h ServiceImplInc.h ServiceImplParam.c ServiceImplParam.h ServiceImplPlateReaction.c ServiceImplPlateReaction.h ServiceImplPlateReagent.c ServiceImplPlateReagent.h ServiceImplPlateWash.c ServiceImplPlateWash.h ServiceImplSensor.c ServiceImplSensor.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask/ServiceImpl/ServiceImplVersion0
    ../TaskMain/ServiceSupport/ServiceTask/ServiceImpl/ServiceImplVersion0/: ServiceImplPlateReagentVersion0.c ServiceImplPlateReagentVersion0.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask/ServiceImpl/ServiceImplVersion1
    ../TaskMain/ServiceSupport/ServiceTask/ServiceImpl/ServiceImplVersion1/: ServiceImplPlateReagentVersion1.c ServiceImplPlateReagentVersion1.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceUtil
    ../TaskMain/ServiceSupport/ServiceUtil/: ServiceUtilMsg.c ServiceUtilMsg.h ServiceUtilMsgDataType.h ServiceUtilMsgDefault.c ServiceUtilMsgDefault.h ServiceUtilMsgIndex.h ServiceUtilParam.c ServiceUtilParam.h ServiceUtilParamDataType.h ServiceUtilParamDefault.c ServiceUtilParamDefault.h ServiceUtilParamIndex.h ServiceUtilPID.c ServiceUtilPID.h
  group UCOS3.07/BSP
    ../../../UCOS3.07/BSP/: bsp_user.c bsp_user.h
  group UCOS3.07/uC-CPU/Port
    ../../../UCOS3.07/uC-CPU/Port/: cpu.h cpu_a.asm cpu_c.c
  group UCOS3.07/uC-CPU/Source
    ../../../UCOS3.07/uC-CPU/Source/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOS3.07/uC-LIB
    ../../../UCOS3.07/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS3.07/uCOS-III/Port
    ../../../UCOS3.07/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS3.07/uCOS-III/Source
    ../../../UCOS3.07/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
