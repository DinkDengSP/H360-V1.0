# IAR project Backup of LH_Cloud_App.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; ARM_MATH_ROUNDING
  ICCARM.CCIncludePath2: ..\..\..\CommonFunc\ADT; ..\..\..\CommonFunc\CanSubSystem; ..\..\..\CommonFunc\SystemUtil; ..\..\..\ThirdParty\bget; ..\..\..\ThirdParty\RTT; ..\..\..\UCOS_III\uC-CPU\Ports; ..\..\..\UCOS_III\uC-CPU; ..\..\..\UCOS_III\uC-LIB; ..\..\..\UCOS_III\uCOS-III\Ports; ..\..\..\UCOS_III\uCOS-III; ..\..\..\Driver\DriverBoard; ..\..\..\Driver\DriverBoard\EC20; ..\..\..\Driver\DriverMCU; ..\..\..\Driver\DriverCore\CMSIS; ..\..\..\Driver\DriverCore\Startup; ..\..\..\Driver\DriverCore\Startup\Linker; ..\..\..\Driver\DriverCore\StdLib\inc; ..\..\..\Driver\DriverCore\StdLib\src; ..\..\..\Driver\DriverCore\StdLibSupport; ..\..\..\Driver\DriverCore\UtilFunc; ..\DriverConfig\BoardConfig; ..\DriverConfig\CoreConfig; ..\DriverConfig\OSConfig; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\ServiceSupport\ServiceImpl; ..\TaskMain\ServiceSupport\ServiceIPC; ..\TaskMain\ServiceSupport\ServiceTask; ..\TaskMain\ServiceSupport\ServiceUtil; ..\TaskMain\AppSupport\AppImpl; ..\TaskMain\AppSupport\AppIPC; ..\TaskMain\AppSupport\AppTask; ..\TaskMain\AppSupport\AppUtil
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Rail_H360_Cloud_V0.1.0.bin
  ILINK.IlinkOutputFile: LH_Cloud_Bootloader.out
  ILINK.IlinkIcfFile: ..\..\..\Driver\DriverCore\Startup\Linker\stm32f407xG_App.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../Driver/DriverBoard/: BoardVersion.c BoardVersion.h
  group CommonFunc/ADT
    ../../../CommonFunc/ADT/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ADT_CirclePtrQueue.c ADT_CirclePtrQueue.h ADT_KMP.c ADT_KMP.h
  group CommonFunc/CanSubSystem
    ../../../CommonFunc/CanSubSystem/: Can1CmdDef.h Can1DataType.h Can1ProcConfig.h Can1ProcMain.c Can1ProcMain.h Can1ProcUtil.c Can1ProcUtil.h
  group CommonFunc/SystemUtil
    ../../../CommonFunc/SystemUtil/: ErrorCode.h SystemCmd.h SystemUtilInc.h SystemVersion.h UserMemManage.c UserMemManage.h
  group Driver/DriverBoard
    ../../../Driver/DriverBoard/: BoardBeep.c BoardBeep.h BoardConfigKey.c BoardConfigKey.h BoardEC20.c BoardEC20.h BoardIAP.c BoardIAP.h BoardInc.h BoardLed.c BoardLed.h BoardMB85RS2MT.c BoardMB85RS2MT.h BoardRS.c BoardRS.h BoardSD.c BoardSD.h BoardSD_Base.h BoardSRAM.c BoardSRAM.h
  group Driver/DriverBoard/EC20
    ../../../Driver/DriverBoard/EC20/: EC20_Command.h EC20_Config.c EC20_Config.h EC20_Inc.h EC20_Port.h EC20_Type.h EC20_Util.c EC20_Util.h
  group Driver/DriverCore/CMSIS
    ../../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Driver/DriverCore/Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s
  group Driver/DriverCore/Startup/Linker
    ../../../Driver/DriverCore/Startup/Linker/: stm32f407xG_App.icf
  group Driver/DriverCore/StdLib/Inc
    ../../../Driver/DriverCore/StdLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Driver/DriverCore/StdLib/Src
    ../../../Driver/DriverCore/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver/DriverCore/StdLibSupport
    ../../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_it.h system_stm32f4xx.h
  group Driver/DriverCore/UtilFunc
    ../../../Driver/DriverCore/UtilFunc/: CoreDelay.c CoreDelay.h CoreInc.h CoreUtil.c CoreUtil.h
  group Driver/DriverMCU
    ../../../Driver/DriverMCU/: MCU_Can.c MCU_Can.h MCU_Common.h MCU_Flash.c MCU_Flash.h MCU_Inc.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SDIO.c MCU_SDIO.h MCU_SDIO_Base.h MCU_SPI.h MCU_SPI2.c MCU_Uart.h MCU_Uart1.c MCU_Uart2.c MCU_Uart3.c MCU_Uart6.c MCU_Wdg.c MCU_Wdg.h
  group ProjectFiles/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
  group ProjectFiles/DriverConfig/OSConfig
    ../DriverConfig/OSConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ProjectFiles/TaskMain
    ../TaskMain/: SystemMain.c SystemStartTask.c SystemTaskConfig.h
  group ProjectFiles/TaskMain/AppSupport/AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskConfig.h AppTaskDemo.c
  group ProjectFiles/TaskMain/ServiceSupport/ServiceImpl
    ../TaskMain/ServiceSupport/ServiceImpl/: ServiceImplBase.h ServiceImplCloudBase.c ServiceImplCloudBase.h ServiceImplCloudNet.c ServiceImplCloudNet.h ServiceImplInc.h
  group ProjectFiles/TaskMain/ServiceSupport/ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskBoardIap.c ServiceTaskCanMsgProc.c ServiceTaskCloudBase.c ServiceTaskCloudNet.c ServiceTaskConfig.h ServiceTaskHeart.c ServiceTaskNetStrengthCheck.c
  group ThirdParty/bget
    ../../../ThirdParty/bget/: bget.c bget.h
  group ThirdParty/RTT
    ../../../ThirdParty/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group UCOS_III/uC-CPU
    ../../../UCOS_III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOS_III/uC-CPU/Ports
    ../../../UCOS_III/uC-CPU/Ports/: bsp_user.c bsp_user.h cpu.h cpu_a.asm cpu_c.c
  group UCOS_III/uC-LIB
    ../../../UCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS_III/uCOS-III
    ../../../UCOS_III/uCOS-III/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group UCOS_III/uCOS-III/Ports
    ../../../UCOS_III/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
