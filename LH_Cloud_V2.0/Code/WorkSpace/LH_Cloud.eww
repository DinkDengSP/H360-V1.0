<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\ProjectCollection\Application\ProjectFiles\LH_Cloud_App.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\ProjectCollection\BootLoader\ProjectFiles\LH_Cloud_Bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
