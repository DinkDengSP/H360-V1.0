/*******************************************************************
 *Description: Copyright(c) 2018-2025 LiHeBio,All rights reserved.
 *Author: DengXiaoJun
 *Date: 2019-12-31 15:45:36
 *LastEditors: DengXiaoJun
 *LastEditTime: 2020-03-05 10:29:48
 *FilePath: \Applicationd:\SVN_Cloud\H200\EmbeddedSoftware\H360\H360MainControlAppV2.2\Code\CommonFunc\Can2SubCommBase\Can2SubStepMotorIndex.h
 *ModifyRecord1:    
 *ModifyRecord2:    
 *ModifyRecord3:    
 *ModifyRecord4:    
 *ModifyRecord5:    
******************************************************************/
#ifndef __CAN2_SUB_STEP_MOTOR_INDEX_H_
#define __CAN2_SUB_STEP_MOTOR_INDEX_H_
#include "ErrorCode.h"

//系统下位机步进电机序号
typedef enum CAN2_SUB_SM_INDEX
{
    //Board1
    CAN2_SUB_SM_BOARD1_SM1,CAN2_SUB_SM_BOARD1_SM2,CAN2_SUB_SM_BOARD1_SM3,CAN2_SUB_SM_BOARD1_SM4,
    CAN2_SUB_SM_BOARD1_SM5,CAN2_SUB_SM_BOARD1_SM6,CAN2_SUB_SM_BOARD1_SM7,CAN2_SUB_SM_BOARD1_SM8,
    CAN2_SUB_SM_BOARD1_SM9,CAN2_SUB_SM_BOARD1_SM10,CAN2_SUB_SM_BOARD1_SM11,CAN2_SUB_SM_BOARD1_SM12,
    //Board2
    CAN2_SUB_SM_BOARD2_SM1,CAN2_SUB_SM_BOARD2_SM2,CAN2_SUB_SM_BOARD2_SM3,CAN2_SUB_SM_BOARD2_SM4,
    CAN2_SUB_SM_BOARD2_SM5,CAN2_SUB_SM_BOARD2_SM6,CAN2_SUB_SM_BOARD2_SM7,CAN2_SUB_SM_BOARD2_SM8,
    CAN2_SUB_SM_BOARD2_SM9,CAN2_SUB_SM_BOARD2_SM10,CAN2_SUB_SM_BOARD2_SM11,CAN2_SUB_SM_BOARD2_SM12,
    //Board3
    CAN2_SUB_SM_BOARD3_SM1,CAN2_SUB_SM_BOARD3_SM2,CAN2_SUB_SM_BOARD3_SM3,CAN2_SUB_SM_BOARD3_SM4,
    CAN2_SUB_SM_BOARD3_SM5,CAN2_SUB_SM_BOARD3_SM6,CAN2_SUB_SM_BOARD3_SM7,CAN2_SUB_SM_BOARD3_SM8,
    CAN2_SUB_SM_BOARD3_SM9,CAN2_SUB_SM_BOARD3_SM10,CAN2_SUB_SM_BOARD3_SM11,CAN2_SUB_SM_BOARD3_SM12,
    //Board4
    CAN2_SUB_SM_BOARD4_SM1,CAN2_SUB_SM_BOARD4_SM2,CAN2_SUB_SM_BOARD4_SM3,CAN2_SUB_SM_BOARD4_SM4,
    CAN2_SUB_SM_BOARD4_SM5,CAN2_SUB_SM_BOARD4_SM6,CAN2_SUB_SM_BOARD4_SM7,CAN2_SUB_SM_BOARD4_SM8,
    CAN2_SUB_SM_BOARD4_SM9,CAN2_SUB_SM_BOARD4_SM10,CAN2_SUB_SM_BOARD4_SM11,CAN2_SUB_SM_BOARD4_SM12,
    //Board5
    CAN2_SUB_SM_BOARD5_SM1,CAN2_SUB_SM_BOARD5_SM2,CAN2_SUB_SM_BOARD5_SM3,CAN2_SUB_SM_BOARD5_SM4,
    CAN2_SUB_SM_BOARD5_SM5,CAN2_SUB_SM_BOARD5_SM6,CAN2_SUB_SM_BOARD5_SM7,CAN2_SUB_SM_BOARD5_SM8,
    CAN2_SUB_SM_BOARD5_SM9,CAN2_SUB_SM_BOARD5_SM10,CAN2_SUB_SM_BOARD5_SM11,CAN2_SUB_SM_BOARD5_SM12,
    //Board6
    CAN2_SUB_SM_BOARD6_SM1,CAN2_SUB_SM_BOARD6_SM2,CAN2_SUB_SM_BOARD6_SM3,CAN2_SUB_SM_BOARD6_SM4,
    CAN2_SUB_SM_BOARD6_SM5,CAN2_SUB_SM_BOARD6_SM6,CAN2_SUB_SM_BOARD6_SM7,CAN2_SUB_SM_BOARD6_SM8,
    CAN2_SUB_SM_BOARD6_SM9,CAN2_SUB_SM_BOARD6_SM10,CAN2_SUB_SM_BOARD6_SM11,CAN2_SUB_SM_BOARD6_SM12,
    //Board7
    CAN2_SUB_SM_BOARD7_SM1,CAN2_SUB_SM_BOARD7_SM2,CAN2_SUB_SM_BOARD7_SM3,CAN2_SUB_SM_BOARD7_SM4,
    CAN2_SUB_SM_BOARD7_SM5,CAN2_SUB_SM_BOARD7_SM6,CAN2_SUB_SM_BOARD7_SM7,CAN2_SUB_SM_BOARD7_SM8,
    CAN2_SUB_SM_BOARD7_SM9,CAN2_SUB_SM_BOARD7_SM10,CAN2_SUB_SM_BOARD7_SM11,CAN2_SUB_SM_BOARD7_SM12,
    //Board8
    CAN2_SUB_SM_BOARD8_SM1,CAN2_SUB_SM_BOARD8_SM2,CAN2_SUB_SM_BOARD8_SM3,CAN2_SUB_SM_BOARD8_SM4,
    CAN2_SUB_SM_BOARD8_SM5,CAN2_SUB_SM_BOARD8_SM6,CAN2_SUB_SM_BOARD8_SM7,CAN2_SUB_SM_BOARD8_SM8,
    CAN2_SUB_SM_BOARD8_SM9,CAN2_SUB_SM_BOARD8_SM10,CAN2_SUB_SM_BOARD8_SM11,CAN2_SUB_SM_BOARD8_SM12,
    //Board9
    CAN2_SUB_SM_BOARD9_SM1,CAN2_SUB_SM_BOARD9_SM2,CAN2_SUB_SM_BOARD9_SM3,CAN2_SUB_SM_BOARD9_SM4,
    CAN2_SUB_SM_BOARD9_SM5,CAN2_SUB_SM_BOARD9_SM6,CAN2_SUB_SM_BOARD9_SM7,CAN2_SUB_SM_BOARD9_SM8,
    CAN2_SUB_SM_BOARD9_SM9,CAN2_SUB_SM_BOARD9_SM10,CAN2_SUB_SM_BOARD9_SM11,CAN2_SUB_SM_BOARD9_SM12,
    //Board10
    CAN2_SUB_SM_BOARD10_SM1,CAN2_SUB_SM_BOARD10_SM2,CAN2_SUB_SM_BOARD10_SM3,CAN2_SUB_SM_BOARD10_SM4,
    CAN2_SUB_SM_BOARD10_SM5,CAN2_SUB_SM_BOARD10_SM6,CAN2_SUB_SM_BOARD10_SM7,CAN2_SUB_SM_BOARD10_SM8,
    CAN2_SUB_SM_BOARD10_SM9,CAN2_SUB_SM_BOARD10_SM10,CAN2_SUB_SM_BOARD10_SM11,CAN2_SUB_SM_BOARD10_SM12,
}CAN2_SUB_SM_INDEX;

#endif




